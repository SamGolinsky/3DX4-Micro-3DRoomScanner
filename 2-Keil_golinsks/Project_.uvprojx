# Keil uVision project Project_.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c PLL.c SysTick.c uart.c vl53l1_platform_2dx4.c VL53L1X_api.c onboardLEDs.c
software components: CMSIS:CORE 5.4.0, Device:Startup 3.2.3
